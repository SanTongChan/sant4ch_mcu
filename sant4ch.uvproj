# Keil uVision project sant4ch.uvproj, settings and files
target sant4ch (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: sant4ch +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\code\key;.\code\logic;.\code\timer;.\code\driver;.\code\led;.\code\common;.\code\flash;.\code\remote
  group timer
    ./code/timer/: timer.c
  group logic
    ./code/logic/: logic.c
  group key
    ./code/key/: key.c
  group startup
    ./: STARTUP.A51
  group sant4ch
    ./code/sant4ch/: main.c
  group driver
    ./code/driver/: key_driver.c
  group led
    ./code/led/: led.c
  group flash
    ./code/flash/: flash.c
  group remote
    ./code/remote/: remote.c
